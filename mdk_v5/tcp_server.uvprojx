# Keil uVision project tcp_server.uvprojx, settings and files
target tcp_server (6220000::V6.22::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: tcp_server +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=3
  c define: AT32F407VGT7,USE_STDPERIPH_DRIVER,AT_START_F407_V1
  c include: ..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\..\at32f403a_407_board;..\..\..\..\..\..\middlewares\3rd_party\lwip_2.1.2\port;..\..\..\..\..\..\middlewares\3rd_party\lwip_2.1.2\port\arch;..\..\..\..\..\..\middlewares\3rd_party\lwip_2.1.2\src\include;..\..\..\..\..\..\middlewares\3rd_party\lwip_2.1.2\src\include\lwip;..\..\..\..\..\..\middlewares\3rd_party\lwip_2.1.2\src\apps\ping
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../src/: at32f403a_407_clock.c at32f403a_407_int.c at32_emac.c main.c netconf.c tcp_server.c
  group bsp
    ../../../../../at32f403a_407_board/: at32f403a_407_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32f403a_407_crm.c at32f403a_407_usart.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_gpio.c at32f403a_407_misc.c at32f403a_407_tmr.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
  group lwip
    ../../../../../../middlewares/3rd_party/lwip_2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../../middlewares/3rd_party/lwip_2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../middlewares/3rd_party/lwip_2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../../middlewares/3rd_party/lwip_2.1.2/src/netif/: ethernet.c
    ../../../../../../middlewares/3rd_party/lwip_2.1.2/port/: ethernetif.c sys_arch.c
  group readme
    ../: readme.txt
